options:
  parameters:
    generate_options: qt_gui
    id: recognizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: Микрофон (Logi C270 HD WebCam)
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\gnuradio_files\records.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      import numpy as np
      from gnuradio import gr
      import wave
      import subprocess
      import tempfile
      import os
      import threading
      import queue
      import time
      from datetime import datetime
      from scipy.signal import butter, lfilter

      class blk(gr.sync_block):
          """
          Долговременное непрерывное распознавание через whisper.cpp.
          Результаты пишутся в файлы с разбиением по часам.
          Работает часами, стабильно.
          """

          def __init__(self,
                       whisper_path="C:/whisper/whisper-cli.exe",
                       model_path="C:/whisper/models/ggml-large-v3.bin",
                       sample_rate=48000,
                       buffer_seconds=10,
                       overlap_seconds=5,
                       output_dir="C:/gnuradio_files",
                       num_workers=2):
              gr.sync_block.__init__(self,
                                     name="Whisper.cpp Continuous Recognition (Hourly Files)",
                                     in_sig=[np.float32],
                                     out_sig=None)

              self.whisper_path = whisper_path
              self.model_path = model_path
              self.sample_rate = sample_rate
              self.buffer_seconds = buffer_seconds
              self.overlap_samples = int(overlap_seconds * sample_rate)
              self.output_dir = output_dir
              self.buffer = []

              if not os.path.exists(self.output_dir):
                  os.makedirs(self.output_dir)

              self.error_log = os.path.join(self.output_dir, "errors.log")
              self.queue = queue.Queue()
              self.stop_event = threading.Event()

              # Текущий часовой файл и handle
              self.current_hour_file = self.get_hour_file_path()
              self.current_hour_file_handle = open(self.current_hour_file, "a", encoding="utf-8")

              # Запуск пула воркеров
              self.num_workers = num_workers
              for _ in range(self.num_workers):
                  threading.Thread(target=self.worker_thread, daemon=True).start()

          def get_hour_file_path(self):
              now = datetime.now()
              filename = f"recognized_{now.strftime('%Y-%m-%d_%H')}.txt"
              return os.path.join(self.output_dir, filename)

          def bandpass_filter(self, data, lowcut=80, highcut=8000, order=5):
              nyq = 0.5 * self.sample_rate
              low = lowcut / nyq
              high = highcut / nyq
              b, a = butter(order, [low, high], btype='band')
              return lfilter(b, a, data)

          def work(self, input_items, output_items):
              # Ограничение пиков и фильтрация
              audio = np.clip(input_items[0], -1.0, 1.0)
              audio = self.bandpass_filter(audio)
              audio = (audio * 32767).astype(np.int16)

              self.buffer.extend(audio)

              if len(self.buffer) >= self.sample_rate * self.buffer_seconds:
                  self.queue.put(self.buffer.copy())
                  # сохраняем последние overlap_samples для скользящего окна
                  self.buffer = self.buffer[-self.overlap_samples:]

              return len(input_items[0])

          def worker_thread(self):
              while not self.stop_event.is_set():
                  try:
                      buffer_data = self.queue.get(timeout=1)
                      self.process_audio(buffer_data)
                  except queue.Empty:
                      continue

          def process_audio(self, buffer_data):
              # Создаем временный WAV файл
              with tempfile.NamedTemporaryFile(delete=False, suffix=".wav") as f:
                  wav_path = f.name

              try:
                  with wave.open(wav_path, "wb") as wf:
                      wf.setnchannels(1)
                      wf.setsampwidth(2)
                      wf.setframerate(self.sample_rate)
                      wf.writeframes(np.array(buffer_data, dtype=np.int16).tobytes())

                  cmd = [
                      self.whisper_path,
                      "-m", self.model_path,
                      "-f", wav_path,
                      "-l", "ru",
                      "--no-timestamps",
                      "--threads", str(os.cpu_count())
                  ]

                  for attempt in range(3):
                      try:
                          si = subprocess.STARTUPINFO()
                          si.dwFlags |= subprocess.STARTF_USESHOWWINDOW

                          result = subprocess.run(
                              cmd,
                              stdout=subprocess.PIPE,
                              stderr=subprocess.PIPE,
                              startupinfo=si,
                              text=True,
                              encoding="utf-8",
                              timeout=120
                          )
                          break
                      except Exception as e:
                          time.sleep(1)
                  else:
                      with open(self.error_log, "a", encoding="utf-8") as f:
                          f.write(f"Failed after 3 attempts: {str(e)}\n")
                      return

                  text = result.stdout.strip()
                  if text:
                      # Проверяем часовой файл
                      now_hour_file = self.get_hour_file_path()
                      if now_hour_file != self.current_hour_file:
                          self.current_hour_file_handle.close()
                          self.current_hour_file = now_hour_file
                          self.current_hour_file_handle = open(self.current_hour_file, "a", encoding="utf-8")

                      self.current_hour_file_handle.write(text + "\n")
                      self.current_hour_file_handle.flush()

              except Exception as e:
                  with open(self.error_log, "a", encoding="utf-8") as f:
                      f.write(str(e) + "\n")
              finally:
                  if os.path.exists(wav_path):
                      os.remove(wav_path)

          def stop(self):
              self.stop_event.set()
              self.current_hour_file_handle.close()
              return super().stop()
    buffer_seconds: '10'
    model_path: '"C:/whisper/models/ggml-small.bin"'
    num_workers: '1'
    output_dir: '"C:/gnuradio_files"'
    overlap_seconds: '5'
    sample_rate: '48000'
    whisper_path: '"C:/whisper/whisper-cli.exe"'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [audio_source_0, '0', high_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [band_pass_filter_0, '0', epy_block_0, '0']
- [high_pass_filter_0, '0', band_pass_filter_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
