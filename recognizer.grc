options:
  parameters:
    generate_options: qt_gui
    id: recognizer
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '48000'
  states: {}
- name: audio_source_0
  id: audio_source
  parameters:
    device_name: Микрофон (Logi C270 HD WebCam)
    samp_rate: samp_rate
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '5000'
    low_cutoff_freq: '200'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: blocks_wavfile_sink_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample1: FORMAT_PCM_16
    file: C:\gnuradio_files\records.wav
    format: FORMAT_WAV
    samp_rate: samp_rate
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: "import numpy as np\nfrom gnuradio import gr\nimport wave\nimport subprocess\nimport tempfile\nimport os\nimport threading\nimport queue\nfrom datetime import datetime\n\nclass blk(gr.sync_block):\n    \"\"\"\n    Долговременное непрерывное распознавание через whisper.cpp.\n    Результаты пишутся в файлы с разбиением по часам.\n    Консоль чистая, работает часами.\n    \"\"\"\n\n    def __init__(self,\n                 whisper_path=\"C:/whisper/whisper-cli.exe\",\n                 model_path=\"C:/whisper/models/ggml-large-v3.bin\",\n                 sample_rate=48000,\n                 buffer_seconds=2,\n                 output_dir=\"C:/gnuradio_files\"):\n        gr.sync_block.__init__(self,\n                               name=\"Whisper.cpp Continuous Recognition (Hourly Files)\",\n                               in_sig=[np.float32],\n                               out_sig=None)  # Нет выхода\n\n        self.whisper_path = whisper_path\n        self.model_path = model_path\n        self.sample_rate = sample_rate\n        self.buffer_seconds = buffer_seconds\n        self.output_dir = output_dir\n        self.buffer = []\n\n        # Проверка директорий\n        if not os.path.exists(self.output_dir):\n            os.makedirs(self.output_dir)\n\n        self.error_log = os.path.join(self.output_dir, \"errors.log\")\n        self.queue = queue.Queue()\n        self.stop_event = threading.Event()\n\n        # Текущий часовой файл\n        self.current_hour_file = self.get_hour_file_path()\n\n        # Запуск фонового потока\n        threading.Thread(target=self.worker_thread, daemon=True).start()\n\n    def get_hour_file_path(self):\n        now = datetime.now()\n        filename = f\"recognized_{now.strftime('%Y-%m-%d_%H')}.txt\"\n        return os.path.join(self.output_dir, filename)\n\n    def work(self, input_items, output_items):\n        audio = (input_items[0] * 32767).astype(np.int16)\n        self.buffer.extend(audio)\n\n        if len(self.buffer) >= self.sample_rate * self.buffer_seconds:\n            # Копируем буфер и отправляем в очередь\n            self.queue.put(self.buffer.copy())\n            self.buffer = []\n\n        return len(input_items[0])\n\n    def worker_thread(self):\n        while not self.stop_event.is_set():\n            try:\n                buffer_data = self.queue.get(timeout=1)\n                self.process_audio(buffer_data)\n            except queue.Empty:\n                continue\n\n    def process_audio(self, buffer_data):\n        # Создаем временный WAV\n        with tempfile.NamedTemporaryFile(delete=False, suffix=\".wav\") as f:\n            wav_path = f.name\n\n        with wave.open(wav_path, \"wb\") as wf:\n            wf.setnchannels(1)\n            wf.setsampwidth(2)\n            wf.setframerate(self.sample_rate)\n            wf.writeframes(np.array(buffer_data, dtype=np.int16).tobytes())\n\n        cmd = [\n            self.whisper_path,\n            \"-m\", self.model_path,\n            \"-f\", wav_path,\n            \"-l\", \"ru\",\n            \"--no-timestamps\"\n        ]\n\n        try:\n            si = subprocess.STARTUPINFO()\n            si.dwFlags |= subprocess.STARTF_USESHOWWINDOW\n\n            result = subprocess.run(\n                cmd,\n                stdout=subprocess.PIPE,\n                stderr=subprocess.PIPE,\n                startupinfo=si,\n                text=True,\n                encoding=\"utf-8\",\n                timeout=120\n            )\n\n            text = result.stdout.strip()\n            if text:\n                # Обновляем текущий часовой файл\n                hour_file = self.get_hour_file_path()\n                if hour_file != self.current_hour_file:\n                    self.current_hour_file = hour_file\n\n                with open(self.current_hour_file, \"a\", encoding=\"utf-8\") as f:\n                    f.write(text + \"\\n\")\n\n        except Exception as e:\n            with open(self.error_log, \"a\", encoding=\"utf-8\") as f:\n                f.write(str(e) + \"\\n\")\n        finally:\n            os.remove(wav_path)\n\n"
    buffer_seconds: '10'
    model_path: '"C:/whisper/models/ggml-small.bin"'
    output_dir: '"C:/gnuradio_files"'
    sample_rate: '48000'
    whisper_path: '"C:/whisper/whisper-cli.exe"'
  states: {}
- name: high_pass_filter_0
  id: high_pass_filter
  parameters:
    cutoff_freq: '50'
    decim: '1'
    gain: '1'
    samp_rate: samp_rate
    type: fir_filter_fff
    width: '100'
    win: window.WIN_HAMMING
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: float
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
  states: {}

connections:
- [audio_source_0, '0', high_pass_filter_0, '0']
- [band_pass_filter_0, '0', blocks_wavfile_sink_0, '0']
- [band_pass_filter_0, '0', epy_block_0, '0']
- [high_pass_filter_0, '0', band_pass_filter_0, '0']
- [high_pass_filter_0, '0', qtgui_freq_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_time_sink_x_0, '0']
- [high_pass_filter_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
